IMAGE_INSTALL += " \
    packagegroup-tdx-qt5 \
"
